# Keil uVision project ProjectTemplate.uvprojx, settings and files
target Template (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ProjectTemplate +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx
  c include: .\User\src;.\User\inc;.\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/src/: main.c led.c beep.c delay.c usart1.c exit.c w25q64.c systick.c key.c spi.c desktop.c lcd.c wifi.c usart2.c
  group CMSIS
    ./CMSIS/: startup_stm32f40_41xxx.s system_stm32f4xx.c stm32f4xx.h system_stm32f4xx.h
